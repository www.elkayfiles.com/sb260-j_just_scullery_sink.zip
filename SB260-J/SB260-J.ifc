Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-12-27T11:46:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Dec 27 11:46:03 2023 * Host: ZIL2DTCLS3 * Database: C:\Users\cdprasad\AppData\Local\Temp\30d0481a-f91d-4480-b3a1-bd862c611d9d\50bfb8d7-445a-40a9-b3f5-6f97a7f88979\ifc * Database version: 5507 * Database creation date: Wed Dec 27 11:46:01 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Dec 27 11:46:01 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Dec 27 11:46:01 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: SB260-J:SB260-J, SB260-J:SB260-J:763063
In: Level 1
Type - Material: Metal - Steel - Stainless - Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: SB260-J
Pset_DistributionFlowElementCommon - Reference: SB260-J; sets with these values: 2
